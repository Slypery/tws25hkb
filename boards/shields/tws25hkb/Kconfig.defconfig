## boards/shields/tws25hkb/Kconfig.defconfig
```kconfig
if SHIELD_TWS25HKB

config ZMK_KEYBOARD_NAME
    default "tws25hkb"

endif # SHIELD_TWS25HKB
```
